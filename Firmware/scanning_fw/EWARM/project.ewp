# IAR project project.ewp, settings and files
configuration STM32F303xC (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303xC ST STM32F303xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F303xC
  ICCARM.IExtraOptions: --diag_warning Pe191; --diag_suppress Pe191; --diag_suppress Pa050
  ICCARM.CCIncludePath2: ..\; ..\System; ..\Display; ..\SignalCapture; ..; ..\nvram; ..\TDC; ..\..\Libraries\STM32F30x_StdPeriph_Driver\inc; ..\..\Libraries\Mavlink; ..\..\Libraries\Mavlink\mavlink_tof
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: D:\MYPROGS\STM32F4\TOF_LASER\TOF_board1\System\stm32f303xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Mavlink
    ../../Libraries/Mavlink/mavlink_tof/: mavlink.h
    ../: mavlink_handling.c
  group NVRAM
    ../nvram/: nvram.c nvram.h stm32f3_flash.c stm32f3_flash.h
  group STM32F30x_SPL
    ../../Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c
  group System
    ../System/: startup_stm32f303xc.s stm32f30x.h system_stm32f30x.c
  group TDC
    ../TDC/: spi_driver.c tdc_driver.c
  group User
    ../: apd_power.c capture_controlling.c config.h dist_measurement.c encoder_processing.c fifo_functions.c hardware.c main.c motor_controlling.c stm32f30x_it.c uart_driver.c
